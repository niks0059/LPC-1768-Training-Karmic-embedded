# Keil uVision project uart.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
    ../../keil_examples/common/src/: core_cm3.c system_LPC17xx.c
    ../../keil_examples/common/inc/: core_cm3.h LPC17xx.h system_LPC17xx.h type.h
    ../../keil_examples/UART/: dma.h uart.h UART.uvgui.embedded UART.uvopt UARTDma.uvopt
